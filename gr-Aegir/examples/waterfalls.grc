options:
  parameters:
    generate_options: qt_gui
    id: untitled2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: Aegir_AegirSDR_0
  id: Aegir_AegirSDR
  parameters:
    address: tcp://localhost:5555
    blocksize: '8192'
    ctrl_address: tcp://localhost:5556
    nchannels: '5'
    timeout_ms: '100'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    int_min: '-100'
    legend: 'False'
    name: '"1"'
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    int_min: '-100'
    legend: 'False'
    name: '"2"'
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    int_min: '-100'
    legend: 'False'
    name: '"3"'
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_waterfall_sink_x_0_2
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    int_min: '-100'
    legend: 'False'
    name: '"4"'
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_waterfall_sink_x_0_3
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    int_min: '-100'
    legend: 'False'
    name: '"5"'
    type: complex
    update_time: '0.05'
  states: {}

connections:
- [Aegir_AegirSDR_0, '0', qtgui_waterfall_sink_x_0, '0']
- [Aegir_AegirSDR_0, '1', qtgui_waterfall_sink_x_0_0, '0']
- [Aegir_AegirSDR_0, '2', qtgui_waterfall_sink_x_0_1, '0']
- [Aegir_AegirSDR_0, '3', qtgui_waterfall_sink_x_0_2, '0']
- [Aegir_AegirSDR_0, '4', qtgui_waterfall_sink_x_0_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
