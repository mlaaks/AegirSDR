options:
  parameters:
    generate_options: qt_gui
    id: gnuradiozmq
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/mikko/AegirSDR/gnuradio/iq.bin
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '5'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
    update_time: '0.05'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
    update_time: '0.05'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
    update_time: '0.05'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
    update_time: '0.05'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
    update_time: '0.05'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    int_min: '-100'
    legend: 'False'
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    int_min: '-100'
    legend: 'False'
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    int_min: '-100'
    legend: 'False'
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    int_min: '-100'
    legend: 'False'
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    int_min: '-100'
    legend: 'False'
    type: complex
    update_time: '0.05'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://127.0.0.1:5555"'
    timeout: '100'
    type: complex
    vlen: '5'
  states: {}

connections:
- [blocks_vector_to_streams_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_vector_to_streams_0, '1', qtgui_freq_sink_x_0_0, '0']
- [blocks_vector_to_streams_0, '1', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_vector_to_streams_0, '2', blocks_file_sink_0, '0']
- [blocks_vector_to_streams_0, '2', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_vector_to_streams_0, '2', qtgui_waterfall_sink_x_0_0_0, '0']
- [blocks_vector_to_streams_0, '3', qtgui_freq_sink_x_0_0_0_0, '0']
- [blocks_vector_to_streams_0, '3', qtgui_waterfall_sink_x_0_0_0_0, '0']
- [blocks_vector_to_streams_0, '4', qtgui_freq_sink_x_0_0_0_0_0, '0']
- [blocks_vector_to_streams_0, '4', qtgui_waterfall_sink_x_0_0_0_0_0, '0']
- [zeromq_sub_source_0, '0', blocks_vector_to_streams_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
