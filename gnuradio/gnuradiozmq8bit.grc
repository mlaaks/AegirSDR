options:
  parameters:
    generate_options: qt_gui
    id: gnuradiozmq
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_char_to_complex_0_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_char_to_complex_0_0_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_char_to_complex_0_0_0_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_char_to_complex_0_0_0_0_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127'
    vector_input: 'True'
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (2, 2,2,2,2)
    num_outputs: '5'
    type: byte
    vlen: '2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://127.0.0.1:5555"'
    timeout: '100'
    type: byte
    vlen: '2'
  states: {}

connections:
- [blocks_interleaved_char_to_complex_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_interleaved_char_to_complex_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_interleaved_char_to_complex_0_0_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [blocks_interleaved_char_to_complex_0_0_0_0, '0', qtgui_waterfall_sink_x_0_0_0_0, '0']
- [blocks_interleaved_char_to_complex_0_0_0_0_0, '0', qtgui_waterfall_sink_x_0_0_0_0_0, '0']
- [blocks_stream_demux_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_stream_demux_0, '1', blocks_interleaved_char_to_complex_0_0, '0']
- [blocks_stream_demux_0, '2', blocks_interleaved_char_to_complex_0_0_0, '0']
- [blocks_stream_demux_0, '3', blocks_interleaved_char_to_complex_0_0_0_0, '0']
- [blocks_stream_demux_0, '4', blocks_interleaved_char_to_complex_0_0_0_0_0, '0']
- [zeromq_sub_source_0, '0', blocks_stream_demux_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
